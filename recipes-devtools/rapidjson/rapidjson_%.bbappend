FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI:append = " file://0002-cmake-Set-minimum-required-version-to-3.5-for-CMake-.patch"
